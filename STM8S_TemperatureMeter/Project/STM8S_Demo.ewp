# IAR project STM8S_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TemperatureMeterV0.5.hex
  ILINK.IlinkOutputFile: STM8S_Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    ../FWlib/src/: stm8s_adc1.c stm8s_awu.c stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c
  group USER
    ../USER/: adc.c apptick.c lcd.c main.c measurement.c MG127.c NTC.c Spi.c stm8s_interruput.c system.c tim1.c uart.c
