# Keil uVision project ToothLight.uvprojx, settings and files
target IK-52832DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52832_qfaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040  CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\ble_racp;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\peer_manager;..\..\components\boards;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\bootloader\ble_dfu;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\cli;..\..\components\libraries\crc16;..\..\components\libraries\crc32;..\..\components\libraries\crypto;..\..\components\libraries\csense;..\..\components\libraries\csense_drv;..\..\components\libraries\delay;..\..\components\libraries\ecc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fifo;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\led_softblink;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\mutex;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\twi_mngr;..\..\components\libraries\twi_sensor;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\modules\nrfx\drivers\include;..\..\app\ble_hrs;..\..\app\ble_uarts;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\ble_services\ble_bas;..\..\app\work_mode_storage;..\..\app\led_ctrl;..\..\app\proc_rex;..\..\app\bat_volt_check
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002ad8 size 0xd528
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c globlevar.c
    ../config/: sdk_config.h
    ../../app/proc_rex/: ProcRex.c
    ../../app/led_ctrl/: led_ctrl.c led_alarm.c
    ../../app/work_mode_storage/: board_flash_fstorage.c
    ../../app/bat_volt_check/: bat_volt_check.c
  group Board Definition
    ../../components/boards/: boards.c
  group Board Support
    ../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
  group nRF_BLE_Services
    ../../app/ble_uarts/: my_ble_uarts.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_pwm.c nrfx_saadc.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../components/libraries/atomic/: nrf_atomic.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/crc16/: crc16.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/fds/: fds.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c nrf_log_backend_uart.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s132_nrf52_7.0.1_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.1
  cpu: as above
  output: s132_nrf52_7.0.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002ad8 size 0xd528
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.2.0, CMSIS:CORE 4.3.0, Device:Startup 8.27.1
